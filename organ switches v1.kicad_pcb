# Repository jhpinder/midi-organ-stops

File README.md:

# midi-organ-stops

Organ stop controls using Kailh switches
Planning to connect 10 of these PCBs together to create a 4x100 array. Only populating the neccesary switches/LEDs.

## KiCad design organ switches v1.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16: LED; LED_D3.0mm
J1, J2: Conn_01x08; PinHeader_1x08_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16: 150; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32: 10K; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16: SW_SPST; Kailh_socket_MX
U1, U2: 74HC165; Texas_Instruments-D0016A-0-0-IPC_A
U3, U4: TLC6C598QPWRQ1; Texas_Instruments-PW0016A-0-0-0; mouser part number 595-TLC6C598QPWRQ1; digikey description IC LED DRIVER PS 50MA 16TSSOP

Connections:
+5V: J1.1, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, SW1.2 (B), SW2.2 (B), SW3.2 (B), SW4.2 (B), SW5.2 (B), SW6.2 (B), SW7.2 (B), SW8.2 (B), SW9.2 (B), SW10.2 (B), SW11.2 (B), SW12.2 (B), SW13.2 (B), SW14.2 (B), SW15.2 (B), SW16.2 (B), U1.16, U2.16, U3.1, U3.7, U4.1, U4.7; also elsewhere on the board
/LED_CLK: J2.3, U3.15, U4.15; also elsewhere on the board
/LED_DIN: J2.1, U3.2
/LED_DOUT: U4.9; also elsewhere on the board
/LED_LOAD: J2.2, U3.10, U4.10; also elsewhere on the board
/SW_CLK: J1.2, U1.2, U2.2; also elsewhere on the board
/SW_DIN: U2.10; also elsewhere on the board
/SW_DOUT: J1.4, U1.9
/SW_LOAD: J1.3, U1.1, U2.1; also elsewhere on the board
GND: J2.4, R17.1, R18.1, R19.1, R20.1, R21.1, R22.1, R23.1, R24.1, R25.1, R26.1, R27.1, R28.1, R29.1, R30.1, R31.1, R32.1, U1.8, U1.15, U2.8, U2.15, U3.8, U3.16, U4.8, U4.16; also elsewhere on the board
unnamed: D1.1 (K), U3.3
unnamed: D1.2 (A), R1.2
unnamed: D2.1 (K), U3.4
unnamed: D2.2 (A), R2.2
unnamed: D3.1 (K), U3.5
unnamed: D3.2 (A), R3.2
unnamed: D4.1 (K), U3.6
unnamed: D4.2 (A), R4.2
unnamed: D5.1 (K), U3.11
unnamed: D5.2 (A), R5.2
unnamed: D6.1 (K), U3.12
unnamed: D6.2 (A), R6.2
unnamed: D7.1 (K), U3.13
unnamed: D7.2 (A), R7.2
unnamed: D8.1 (K), U3.14
unnamed: D8.2 (A), R8.2
unnamed: D9.1 (K), U4.3
unnamed: D9.2 (A), R9.2
unnamed: D10.1 (K), U4.4
unnamed: D10.2 (A), R10.2
unnamed: D11.1 (K), U4.5
unnamed: D11.2 (A), R11.2
unnamed: D12.1 (K), U4.6
unnamed: D12.2 (A), R12.2
unnamed: D13.1 (K), U4.11
unnamed: D13.2 (A), R13.2
unnamed: D14.1 (K), U4.12
unnamed: D14.2 (A), R14.2
unnamed: D15.1 (K), U4.13
unnamed: D15.2 (A), R15.2
unnamed: D16.1 (K), U4.14
unnamed: D16.2 (A), R16.2
unnamed: R17.2, SW1.1 (A), U1.11
unnamed: R18.2, SW2.1 (A), U1.12
unnamed: R19.2, SW3.1 (A), U1.13
unnamed: R20.2, SW4.1 (A), U1.14
unnamed: R21.2, SW5.1 (A), U1.3
unnamed: R22.2, SW6.1 (A), U1.4
unnamed: R23.2, SW7.1 (A), U1.5
unnamed: R24.2, SW8.1 (A), U1.6
unnamed: R25.2, SW9.1 (A), U2.11
unnamed: R26.2, SW10.1 (A), U2.12
unnamed: R27.2, SW11.1 (A), U2.13
unnamed: R28.2, SW12.1 (A), U2.14
unnamed: R29.2, SW13.1 (A), U2.3
unnamed: R30.2, SW14.1 (A), U2.4
unnamed: R31.2, SW15.1 (A), U2.5
unnamed: R32.2, SW16.1 (A), U2.6
unnamed: U1.10, U2.9
unnamed: U3.9, U4.2

Board: 2 copper layers, 76.2 x 76.3 mm, 80 parts (40 on the bottom side), 60 nets.

Other parts of the board:
C1, C2, C3, C4: 0.1uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
H1, H2, H3, H4: MountingHole; MountingHole_3mm
J3, J4: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical

Their connections:
+5V: C1.1, C2.1, C3.1, C4.1, J3.1; also elsewhere on the board
/LED_CLK: J4.3; also elsewhere on the board
/LED_DOUT: J4.1; also elsewhere on the board
/LED_LOAD: J4.2; also elsewhere on the board
/SW_CLK: J3.2; also elsewhere on the board
/SW_DIN: J3.4; also elsewhere on the board
/SW_LOAD: J3.3; also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.2, J4.4; also elsewhere on the board

## KiCad design org-switches-test.kicad_pcb

Board: 2 copper layers, 20 parts (0 on the bottom side), 21 nets.

Parts:
RN1, RN2: R_Network08_US; R_Array_SIP9
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16: SW_SPST; Kailh_socket_MX
U1: SN74HC165DR; Texas_Instruments-D0016A-0-0-MFG
U2: SN74HC165DR; Texas_Instruments-D0016A-0-0-IPC_A

Connections:
+5V: SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, SW7.2, SW8.2, SW9.2, SW10.2, SW11.2, SW12.2, SW13.2, SW14.2, SW15.2, SW16.2, U1.16, U2.16
GND: RN1.1, RN2.1, U1.8, U1.15, U2.8, U2.15
unnamed: RN1.2, SW8.1, U1.6
unnamed: RN1.3, SW7.1, U1.5
unnamed: RN1.4, SW6.1, U1.4
unnamed: RN1.5, SW5.1, U1.3
unnamed: RN1.6, SW4.1, U1.14
unnamed: RN1.7, SW3.1, U1.13
unnamed: RN1.8, SW2.1, U1.12
unnamed: RN1.9, SW1.1, U1.11
unnamed: RN2.2, SW16.1, U2.6
unnamed: RN2.3, SW15.1, U2.5
unnamed: RN2.4, SW14.1, U2.4
unnamed: RN2.5, SW13.1, U2.3
unnamed: RN2.6, SW12.1, U2.14
unnamed: RN2.7, SW11.1, U2.13
unnamed: RN2.8, SW10.1, U2.12
unnamed: RN2.9, SW9.1, U2.11
unnamed: U1.1, U2.1
unnamed: U1.2, U2.2
unnamed: U1.9, U2.10

## Commit log

2020-09-12 init commit
2020-09-13 first experiments
2020-09-15 pcb component layout complete, no traces
2020-09-15 draft of traces
2020-09-16 addressed items 2, 5, 7, 9 from pinderh
2020-09-17 addressed item 8 from pinderh
2020-09-17 updated pcb
2020-09-20 updated resistor locations away from switch sockets
